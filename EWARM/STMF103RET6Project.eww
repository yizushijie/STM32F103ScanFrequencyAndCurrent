<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STMF103RET6Project.ewp</path>
  </project>
  <batchBuild />
</workspace>
